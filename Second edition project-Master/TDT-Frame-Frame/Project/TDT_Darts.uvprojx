# Keil uVision project TDT_Darts.uvprojx, settings and files
target TDT_Darts (6140000::V6.14::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TDT_Darts +hex
  c flags: Optim=1 OneElfS=1 v6Lang=4 v6LangP=4 wLevel=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,USE_MAIN_CTRL_2020
  c misc: -frtti -Wno-invalid-source-encoding
  c include: ..\ST_Lib\inc;..\User;..\DSP_Lib;..\TDT_Bsp\inc;..\TDT_Alg\inc;..\FreeRTOS\include;..\FreeRTOS\portable\GCC\ARM_CM4F;..\TDT_Devce\inc;..\TDT_Task\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.cpp stm32f4xx_it.c readme.txt
    ../TDT_Task/src/: board.cpp cycle.cpp
  group TDT_Task
    ../TDT_Task/src/: start_task.cpp task_virtual.cpp dbus_task.cpp imu_task.cpp led_task.cpp error_task.cpp dbug_task.cpp flash_var.cpp chassis.cpp rescue_task.cpp paving_task.cpp
  group TDT_Alg
    ../TDT_Alg/src/: pid.cpp crc.cpp filter.cpp imu.cpp my_math.cpp can_calculate.cpp curve_model.cpp mecanum.cpp AHRS_middleware.c AHRS.lib TimeMatch.cpp KeyProcess.cpp
  group TDT_Bsp
    ../TDT_Bsp/src/: spi.cpp can.cpp iwdg.cpp timer.cpp iic.cpp
    ../TDT_Devce/src/: vision.cpp
  group TDT_Device
    ../TDT_Devce/src/: dbus.cpp led.cpp motor.cpp mpu6050.cpp oled.cpp icm20602.cpp icm42605.cpp LCD.cpp key.cpp judgement.cpp switch.cpp usart_DMA.cpp
  group ST_Lib
    ../ST_Lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c system_stm32f4xx.c
    ../ST_Lib/: startup_stm32f40_41xxx.s
  group DSP_Lib
    ../DSP_Lib/: arm_cortexM4lf_math.lib
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/GCC/ARM_CM4F/: port.c
